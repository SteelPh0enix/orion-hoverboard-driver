# Keil uVision project orion_bldc.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: GD32F130C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.1.1
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: orion_bldc +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6 wLevel=4
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src
    ./: main.c bldc.c interrupts.c comms.c init.c globals.c systick.c
  group inc
    ./: init.h globals.h bldc.h interrupts.h comms.h systick.h defines.h
software components: CMSIS:CORE 5.3.0, Device:GD32F1x0_StdPeripherals:ADC 3.1.0, Device:GD32F1x0_StdPeripherals:CRC 3.1.0, Device:GD32F1x0_StdPeripherals:DAC 3.1.0, Device:GD32F1x0_StdPeripherals:DMA 3.1.0, Device:GD32F1x0_StdPeripherals:EXTI 3.1.0, Device:GD32F1x0_StdPeripherals:FMC 3.1.0, Device:GD32F1x0_StdPeripherals:FWDGT 3.1.0, Device:GD32F1x0_StdPeripherals:GPIO 3.1.0, Device:GD32F1x0_StdPeripherals:IVREF 3.1.0, Device:GD32F1x0_StdPeripherals:MCUDBG 3.1.0, Device:GD32F1x0_StdPeripherals:MISC 3.1.0, Device:GD32F1x0_StdPeripherals:PMU 3.1.0, Device:GD32F1x0_StdPeripherals:RCU 3.1.0, Device:GD32F1x0_StdPeripherals:SYSCFG 3.1.0, Device:GD32F1x0_StdPeripherals:TIMER 3.1.0, Device:GD32F1x0_StdPeripherals:USART 3.1.0, Device:GD32F1x0_StdPeripherals:WWDGT 3.1.0, Device:GD32F1x0_libopt 3.1.0, Device:Startup 3.1.0
